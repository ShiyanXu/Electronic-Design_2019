# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: G:\keil5\TivaWare_C_Series-2.1.4.178;.\BSP\EXTI;.\BSP\GPIO;.\BSP\PWM;.\BSP\TIMER;G:\keil5\TivaWare_C_Series-2.1.4.178\utils;.\BSP\UART
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: test.c
    ./BSP/EXTI/: EXTI.c
    ./BSP/TIMER/: TIM.c
    ./BSP/GPIO/: myGPIO.c
    ./BSP/PWM/: mypwm.c
    ./BSP/UART/: myuart.c
  group Library
    G:/keil5/TivaWare_C_Series-2.1.4.178/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    G:/keil5/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1
